# Keil uVision project lab2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4R5ZITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x000A0000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Exp_2
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Source Group 1
    ./: switch_source.h switch_source.s timer_source.s conversion_source.s
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L4R5ZITx/STCubeGenerated/Src/: main.c stm32l4xx_it.c
    ./RTE/Device/STM32L4R5ZITx/STCubeGenerated/Inc/: stm32l4xx_it.h
software components: CMSIS:CORE 5.3.0, Device:STM32Cube HAL:Common 1.11.0, Device:STM32Cube HAL:Cortex 1.11.0, Device:STM32Cube HAL:DMA 1.11.0, Device:STM32Cube HAL:GPIO 1.11.0, Device:STM32Cube HAL:PWR 1.11.0, Device:STM32Cube HAL:RCC 1.11.0, Device:STM32Cube HAL:UART 1.11.0, Device:Startup 1.3.1
